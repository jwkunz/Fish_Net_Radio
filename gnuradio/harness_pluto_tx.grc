options:
  parameters:
    author: Jakob Kunzler
    generate_options: qt_gui
    id: harness_pluto_tx
    output_language: python
    title: Harness of ADALM Pluto TX
  states: {}

blocks:
- name: baseband_rate
  id: variable
  parameters:
    value: int(96E3)
  states: {}
- name: center_frequency
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 1,4,1,1
    lbl: Carrier Frequency
    maxFreqHz: 928E6
    minFreqHz: 902E6
    value: 915E6
  states: {}
- name: channel_offset_hz
  id: variable
  parameters:
    value: int(200E3)
  states: {}
- name: enable_gui
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,4,1,1
    initPressed: 'True'
    label: Enable  GUI
    pressed: '1'
    released: '0'
    type: int
    value: '1'
  states: {}
- name: enable_tx
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,3,1,1
    initPressed: 'True'
    label: RF ON
    pressed: '1'
    released: '0'
    type: bool
    value: '1'
  states: {}
- name: gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,3,1,1
    label: DSP Gain (dB)
    start: '-60'
    step: '3'
    stop: '60'
    value: '0'
  states: {}
- name: pluto_uri
  id: variable
  parameters:
    value: iio.get_pluto_uri()
  states: {}
- name: radio_attenuation_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Radio Attenuation (dB)
    start: '0'
    step: '3'
    stop: '40'
    value: '0'
  states: {}
- name: radio_source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,4,1,1
    label: Radio Source
    label0: Zero
    label1: Wavegenerator
    label2: f"ZMQ Port:{zmq_base_port+zmq_pull_offset}"
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1E6)
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,3,1,1
    label: Waveform Type
    labels: '["Constant","Cosine","Square","Triangle","Saw Tooth","Noise"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5]'
    type: int
    value: '1'
  states: {}
- name: waveform_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,4,1,1
    label: Waveform Frequency
    start: '-samp_rate*0.5'
    step: '1'
    stop: samp_rate*0.5
    value: '1000'
    widget: eng_slider
  states: {}
- name: waveform_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,3,1,1
    label: Waveform Offset
    start: '-1.0'
    step: '1E-6'
    stop: '1.0'
    value: '0.0'
    widget: eng_slider
  states: {}
- name: waveform_phase
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,4,1,1
    label: Waveform Phase (normalized)
    start: '-1.0'
    step: '1E-6'
    stop: '1.0'
    value: '0.0'
    widget: eng_slider
  states: {}
- name: zmq_base_port
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: zmq_pull_offset
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: waveform_frequency
    offset: waveform_offset
    phase: waveform_phase*2.0*357/113
    samp_rate: baseband_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: waveform_frequency
    offset: waveform_offset
    phase: waveform_phase*2.0*357/113
    samp_rate: baseband_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: waveform_frequency
    offset: waveform_offset
    phase: waveform_phase*2.0*357/113
    samp_rate: baseband_rate
    type: complex
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: waveform_frequency
    offset: waveform_offset
    phase: waveform_phase*2.0*357/113
    samp_rate: baseband_rate
    type: complex
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: waveform_frequency
    offset: waveform_offset
    phase: waveform_phase*2.0*357/113
    samp_rate: baseband_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: channel_offset_hz
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(gain_db/20)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enable_gui
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enable_tx
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: radio_source
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: waveform
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: radio_attenuation_db
    bandwidth: '20000000'
    buffer_size: int(samp_rate)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_frequency-channel_offset_hz)
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto_uri
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '16'
    rrate: samp_rate / baseband_rate
    type: ccf
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency-channel_offset_hz
    fftsize: '1024'
    gui_hint: 0,0,5,3
    name: '"ADALM Pluto Receiver"'
    showrf: 'True'
    type: complex
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: f"tcp://127.0.0.1:{zmq_base_port+zmq_pull_offset}"
    bind: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_selector_1_0, '5']
- [analog_sig_source_x_0, '0', blocks_selector_1_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_selector_1_0, '2']
- [analog_sig_source_x_0_0_0, '0', blocks_selector_1_0, '3']
- [analog_sig_source_x_0_0_0_0, '0', blocks_selector_1_0, '4']
- [analog_sig_source_x_0_0_0_0_0, '0', blocks_selector_1_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_selector_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_selector_0_0, '0']
- [blocks_null_source_0, '0', blocks_selector_1, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', qtgui_sink_x_0, '0']
- [blocks_selector_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_selector_0_0, '1', iio_pluto_sink_0, '0']
- [blocks_selector_1, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_selector_1_0, '0', blocks_selector_1, '1']
- [pfb_arb_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [zeromq_pull_source_0, '0', blocks_selector_1, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

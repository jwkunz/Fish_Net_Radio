options:
  parameters:
    author: Jakob Kunzler
    generate_options: qt_gui
    id: harness_hackrf_rx
    output_language: python
    title: Harness of HackRF RX
  states: {}

blocks:
- name: baseband_rate
  id: variable
  parameters:
    value: int(96E3)
  states: {}
- name: center_frequency
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,5,1,1
    lbl: Carrier Frequency
    maxFreqHz: 928E6
    minFreqHz: 902E6
    value: 915E6
  states: {}
- name: channel_offset_hz
  id: variable
  parameters:
    value: int(200E3)
  states: {}
- name: enable_rx
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,0,1,1
    initPressed: 'True'
    label: Enable GUI
    pressed: '1'
    released: '0'
    type: int
    value: '1'
  states: {}
- name: enable_zmq
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,4,1,1
    initPressed: 'False'
    label: f"Enable ZMQ Port {zmq_base_port+zmq_push_offset}"
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: if_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: IF Gain (dB)
    start: '0'
    step: '3'
    stop: '40'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1E6)
  states: {}
- name: tune_hz
  id: variable
  parameters:
    value: '-21000'
  states: {}
- name: vga_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: VGA Gain (dB)
    start: '0'
    step: '3'
    stop: '62'
    value: '57'
  states: {}
- name: zmq_base_port
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: zmq_push_offset
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-channel_offset_hz'
    sample_rate: samp_rate
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enable_zmq
    type: complex
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enable_rx
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '16'
    rrate: 'baseband_rate/samp_rate '
    type: ccf
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: baseband_rate
    fc: center_frequency
    fftsize: '1024'
    gui_hint: 1,0,4,5
    name: '"ADALM Pluto Receiver"'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: center_frequency+tune_hz-channel_offset_hz
    gain: if_gain_db
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain_db
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: f"tcp://127.0.0.1:{zmq_base_port+zmq_push_offset}"
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_freqshift_cc_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_selector_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_selector_0_0_0, '1', zeromq_push_sink_0_0, '0']
- [blocks_selector_0_1, '0', blocks_null_sink_0_1, '0']
- [blocks_selector_0_1, '1', qtgui_sink_x_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_selector_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_selector_0_1, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

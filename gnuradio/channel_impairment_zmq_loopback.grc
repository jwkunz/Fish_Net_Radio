options:
  parameters:
    author: Jakob Kunzler
    generate_options: qt_gui
    id: simple_zmq_loopback
    output_language: python
    title: Simple ZMQ Loopback
  states: {}

blocks:
- name: channel_doppler_hz
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Channel Doppler (Hz)
    start: '-samp_rate*0.5'
    step: '1'
    stop: samp_rate*0.5
    value: '0.0'
  states: {}
- name: channel_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Channel Gain (dB)
    start: '-60.0'
    step: '0.5'
    stop: '10.0'
    value: '0.0'
  states: {}
- name: channel_noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Noise Voltage
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1E6)
  states: {}
- name: zmq_input_port
  id: variable
  parameters:
    value: '20002'
  states: {}
- name: zmq_output_port
  id: variable
  parameters:
    value: '20001'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: channel_noise_voltage
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: channel_doppler_hz
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(channel_gain_db/20.0)
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0.0'
    fftsize: '1024'
    gui_hint: 1,0,4,2
    name: '"Simple ZMQ Loopback"'
    showrf: 'True'
    type: complex
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: f"tcp://127.0.0.1:{zmq_input_port}"
    bind: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: f"tcp://127.0.0.1:{zmq_output_port}"
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_add_xx_0, '0', zeromq_push_sink_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_freqshift_cc_0, '0']
- [zeromq_pull_source_0, '0', blocks_multiply_const_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
